# Repository Durburz/interphase

File README.md:

# interphase

interphase is a open-source mechanical keyboard.
Kudos to reversebias, as I got inspired by his fascinating mitosis keyboard (https://github.com/reversebias/mitosis-hardware).
The only problem was the lack of keys for a full german layout + number row.

Therefor, interphase is a kind of ISO-compatible layout with some minor modifications.

Update on battery life: The AAA batteries (Duracell) per keyboard-half are still going strong. After 5 months of heavy usage at work, they only dropped to ~1.4V. Therefor the total lifetime of the batteries will be approximateley 1 - 1.5 years, as the voltage regulator will work down to 0.35V.

As identified in https://github.com/Durburz/interphase-firmware/issues/6 it is strictly necessary to use the C variant of the MCP1640

## KiCad design interphase.kicad_pcb

Parts:
BT1: Battery_Cell; KEYSTONE-82_AAA_battery-clip
C1, C3: 4,7µF; C_0805_HandSoldering
C2, C4: 10µF; C_0805_HandSoldering
D1, D2, D3, D4, D5, D6, D7, D8, D9, D10, D11, D12, D13, D14, D15, D16, D17, D18, D19, D20, D21, D22, D23, D24, D25, D26, D27, D28, D29, D30, D31, D32, D33, D34, D35, D36, D37, D38, D39, D40, D41, D42, D43, D44, D45, D46, D47, D48, D49, D50, D51, D52, D53, D54, D55, D56, D57, D58, D59, D60, D61, D62, D63, D64, D65, D66: D; D_MiniMELF
J1: Conn_01x04_Male; Pin_Header_Angled_1x04_Pitch2.54mm
L1, L2: 4,7µH; SMD-1206_Pol
R1, R6: 536K; R_0805
R2, R7: 309K; R_0805
SW2, SW3, SW4, SW6, SW7, SW8, SW9, SW11, SW12, SW13, SW14, SW15, SW16, SW17, SW18, SW19, SW20, SW21, SW22, SW23, SW24, SW25, SW27, SW28, SW29, SW30, SW32, SW33, SW34, SW35: MOM-SPST; CHERRY-MX_double_bo_nodiode
SW5: MOM-SPST; CHERRY-MX_double_bo_2u_nodiode
SW26, SW31: MOM-SPST; CHERRY-MX_double_bo_1_5u
U1, U4: Core51822B; Core51822(B)
U2, U3: MCP1640; SOT-23-6

Connections:
+3V3: C2.1, C4.1, J1.1, R1.1, R6.1, U1.12 (VCC), U2.5 (VOUT), U3.5 (VOUT), U4.12 (VCC)
GND: BT1.2 (-), C1.2, C2.2, C3.2, C4.2, J1.4, R2.2, R7.2, U1.1 (GND), U1.11 (GND), U2.2 (GND), U3.2 (GND), U4.1 (GND), U4.11 (GND)
unnamed: D1.1 (K), D2.1 (K), D3.1 (K), D4.1 (K), D5.1 (K), U1.20 (P06), U4.17 (P03)
unnamed: D1.2 (A), D9.2 (A), SW2.2
unnamed: D2.2 (A), D35.2 (A), SW3.2
unnamed: D3.2 (A), D36.2 (A), SW4.2
unnamed: D6.1 (K), D7.1 (K), D8.1 (K), D10.1 (K), U1.19 (P05), U4.18 (P04)
unnamed: D10.2 (A), D42.2 (A), SW11.2
unnamed: D11.1 (K), D12.1 (K), D13.1 (K), D14.1 (K), D15.1 (K), U1.18 (P04), U4.19 (P05)
unnamed: D11.2 (A), D43.2 (A), SW12.2
unnamed: D12.2 (A), D44.2 (A), SW13.2
unnamed: D13.2 (A), D45.2 (A), SW14.2
unnamed: D14.2 (A), D46.2 (A), SW15.2
unnamed: D15.2 (A), D47.2 (A), SW16.2
unnamed: D16.1 (K), D17.1 (K), D18.1 (K), D19.1 (K), D20.1 (K), U1.17 (P03), U4.20 (P06)
unnamed: D16.2 (A), D48.2 (A), SW17.2
unnamed: D17.2 (A), D49.2 (A), SW18.2
unnamed: D18.2 (A), D50.2 (A), SW19.2
unnamed: D19.2 (A), D51.2 (A), SW20.2
unnamed: D20.2 (A), D52.2 (A), SW21.2
unnamed: D21.1 (K), D22.1 (K), D23.1 (K), D24.1 (K), D25.1 (K), U1.16 (P02), U4.21 (P07)
unnamed: D21.2 (A), D53.2 (A), SW22.2
unnamed: D22.2 (A), D54.2 (A), SW23.2
unnamed: D23.2 (A), D55.2 (A), SW24.2
unnamed: D24.2 (A), D56.2 (A), SW25.2
unnamed: D25.2 (A), D57.2 (A), SW26.2
unnamed: D26.1 (K), D27.1 (K), D28.1 (K), D29.1 (K), D30.1 (K), U1.14 (P00), U4.23 (P09)
unnamed: D26.2 (A), D58.2 (A), SW27.2
unnamed: D27.2 (A), D59.2 (A), SW28.2
unnamed: D28.2 (A), D60.2 (A), SW29.2
unnamed: D29.2 (A), D61.2 (A), SW30.2
unnamed: D30.2 (A), D62.2 (A), SW31.2
unnamed: D31.1 (K), D32.1 (K), D33.1 (K), D34.1 (K), U1.13 (P30), U4.24 (P10)
unnamed: D31.2 (A), D63.2 (A), SW32.2
unnamed: D32.2 (A), D64.2 (A), SW33.2
unnamed: D33.2 (A), D65.2 (A), SW34.2
unnamed: D34.2 (A), D66.2 (A), SW35.2
unnamed: D4.2 (A), D37.2 (A), SW5.2
unnamed: D5.2 (A), D38.2 (A), SW6.2
unnamed: D6.2 (A), D39.2 (A), SW7.2
unnamed: D7.2 (A), D40.2 (A), SW8.2
unnamed: D8.2 (A), D41.2 (A), SW9.2
unnamed: J1.2, U1.32 (SWCLK), U4.32 (SWCLK)
unnamed: J1.3, U1.31 (SWDIO), U4.31 (SWDIO)
unnamed: L1.2, U2.1 (SW)
unnamed: L2.2, U3.1 (SW)
unnamed: R1.2, R2.1, U2.4 (VFB)
unnamed: R6.2, R7.1, U3.4 (VFB)
unnamed: SW6.1, SW11.1, SW16.1, SW21.1, SW26.1, SW31.1, U1.10 (P29), U4.27 (P13)
unnamed: SW2.1, SW7.1, SW12.1, SW17.1, SW22.1, SW27.1, SW32.1, U1.9 (P28), U4.28 (P14)
unnamed: SW3.1, SW8.1, SW13.1, SW18.1, SW23.1, SW28.1, SW33.1, U1.4 (P23), U4.33 (P17)
unnamed: SW4.1, SW9.1, SW14.1, SW19.1, SW24.1, SW29.1, SW34.1, U1.3 (P22), U4.34 (P18)
unnamed: SW5.1, SW15.1, SW20.1, SW25.1, SW30.1, SW35.1, U1.2 (P21), U4.35 (P19)

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
Board: 2 copper layers, 142.2 x 132.1 mm, 115 parts (40 on the bottom side), 54 nets.

## Commit log

2017-09-13 Create LICENSE
2017-09-13 added GITIGNORE
2017-09-19 schematic preversion and layout preversion
2017-09-21 some work
2017-09-26 routing
2017-09-26 wololo
2017-09-27 edit readme
2017-09-27 netlist to gitignore
2017-09-27 tidy up
2017-09-27 repositioning and routing
2017-09-28 more routing
2017-10-04 re-routing
2017-10-05 finish routing
2017-10-05 prettify
2017-10-19 add layout
2017-11-30 finish layout and fix prototype issues
2018-05-30 added kicad libraries as submodules
2019-05-09 Minor typo fixed
2022-06-08 add picture
